FILESEXTRAPATHS:prepend := "${THISDIR}/linux-toradex:"

SRC_URI += "\ 
    file://0001-webinar-rtc-hwmon.patch \
    file://drivers.cfg \
"